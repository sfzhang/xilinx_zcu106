SRC_URI_append = " \
        file://0001-Added-NULL-reference-check-for-connector-state.patch \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
